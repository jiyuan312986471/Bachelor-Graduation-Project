# Keil uVision project emWin.uvproj, settings and files
target emWin (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: emWin +hex
  c flags: Optim=1
  c define: TSC_DBG FONT_IN_FLASH
  c include: E:\Keil\ARM\Segger\emWin\GUI\Include;..\CommSrc;..\include
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x4000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Statrup
    ./Startup/: RTX_Conf_CM.c system_LPC177x_8x.c startup_LPC177x_8x.s
  group Src
    ./Src/: main.c 宋体24.c Algerian24.c TOUCH_Calibrate.c TOUCH_Sample.c WIDGET_NumPad.c WIDGET_Menu.c WIDGET_PopupMenu.c WIDGET_ListBox.c WIDGET_ListView.c WIDGET_ListWheel.c nhn_opPfmSlot.c STLITI.c ST_GB231224.c DIALOG_NestedModal.c apSet.c WIDGET_Checkbox.c BitmapBar.c BitmapCheckXL.c BitmapCheckXXL.c DIALOG_All.c cpltfmFrm.c
  group GUI
    ./GUI/: GUI_X.c GUIConf.c
  group Lib
    ./GUI/: GUI_TTF.lib
    E:/Keil/MDK.V4.70/ARM/Segger/emWin/Lib/: GUI_CM3.lib
  group Driver
    ./Driver/: LCD_X_LPC177x_8x.c LCDConf.c
    ../CommSrc/: JS28F128.c sdram.c TSC_2046.c MX29LV640E_Drv.c
  group OPPFC-View
    ./Src/: cpltfmSlt_Ftx.c cpltfmSlt_OR.c cpltfmSlt.c cpltfmSlt_Chassis.c cpltfmSlt_Fan.c cpltfmSlt_PS.c setAP.c cpltfmEdfa.c
  group Resources
    ./Src/: alarm_pic.c
    ./: logo_nhn.c
  group OPPFC-Data
    ./Src/: OPPFCData.c
target emWin_SLK (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: emWin_SLK
  c flags: Optim=1
  c define: TSC_DBG, SLK_BOARD
  c include: C:\Keil\ARM\Segger\emWin\Include;..\CommSrc;..\include
  library: MicroLIB
  memory RVCT1: ROM 0x80000000 size 0x1000000
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0xa0000000 size 0x4000000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
